# Keil uVision project secure_dfu_ble_s132_pca10040_debug.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_DFU_DEBUG_VERSION NRF_DFU_SETTINGS_VERSION=1 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0 DFU_APP_DATA_RESERVED=CODE_PAGE_SIZE*6
  c misc: --reduce_paths
  c include: ..\..\..\..\external\sdk13_override;..\..\config;..\..\..\..\external\sdk13\components;..\..\..\..\external\sdk13\components\ble\common;..\..\..\..\external\sdk13\components\boards;..\..\..\..\external\sdk13\components\drivers_nrf\clock;..\..\..\..\external\sdk13\components\drivers_nrf\common;..\..\..\..\external\sdk13\components\drivers_nrf\delay;..\..\..\..\external\sdk13\components\drivers_nrf\hal;..\..\..\..\external\sdk13\components\drivers_nrf\rng;..\..\..\..\external\sdk13\components\libraries\bootloader;..\..\..\..\external\sdk13\components\libraries\bootloader\ble_dfu;..\..\..\..\external\sdk13\components\libraries\bootloader\dfu;..\..\..\..\external\sdk13\components\libraries\crc32;..\..\..\..\external\sdk13\components\libraries\crypto;..\..\..\..\external\sdk13\components\libraries\crypto\backend\micro_ecc;..\..\..\..\external\sdk13\components\libraries\crypto\backend\nrf_crypto_sw;..\..\..\..\external\sdk13\components\libraries\experimental_section_vars;..\..\..\..\external\sdk13\components\libraries\fstorage;..\..\..\..\external\sdk13\components\libraries\hci;..\..\..\..\external\sdk13\components\libraries\log;..\..\..\..\external\sdk13\components\libraries\log\src;..\..\..\..\external\sdk13\components\libraries\mem_manager;..\..\..\..\external\sdk13\components\libraries\queue;..\..\..\..\external\sdk13\components\libraries\scheduler;..\..\..\..\external\sdk13\components\libraries\sha256;..\..\..\..\external\sdk13\components\libraries\strerror;..\..\..\..\external\sdk13\components\libraries\svc;..\..\..\..\external\sdk13\components\libraries\timer;..\..\..\..\external\sdk13\components\libraries\util;..\..\..\..\external\sdk13\components\softdevice\common\softdevice_handler;..\..\..\..\external\sdk13\components\softdevice\s132\headers;..\..\..\..\external\sdk13\components\softdevice\s132\headers\nrf52;..\..\..\..\external\sdk13\components\toolchain;..\..;..\..\..\dfu_req_handling;..\..\..\..\external\sdk13\external\micro-ecc\micro-ecc;..\..\..\..\external\nano-pb;..\..\..\..\external\segger_rtt;..\config;..\..\..\..\include\board;..\..\..\..\include\drivers;..\..\..\..\external\sdk13\components\drivers_nrf\twi_master;..\..\..\..\include\util;..\..\..\..\include\macros
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_DFU_DEBUG_VERSION NRF_DFU_SETTINGS_VERSION=1 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74,-DNRF_DFU_DEBUG_VERSION,-DNRF_DFU_SETTINGS_VERSION=1,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0,-D__HEAP_SIZE=0
  asm include: ..\..\config\secure_dfu_ble_s132_pca10040_debug;..\..\config;..\..\..\..\external\sdk13\components;..\..\..\..\external\sdk13\components\ble\common;..\..\..\..\external\sdk13\components\boards;..\..\..\..\external\sdk13\components\drivers_nrf\clock;..\..\..\..\external\sdk13\components\drivers_nrf\common;..\..\..\..\external\sdk13\components\drivers_nrf\delay;..\..\..\..\external\sdk13\components\drivers_nrf\hal;..\..\..\..\external\sdk13\components\drivers_nrf\rng;..\..\..\..\external\sdk13\components\libraries\bootloader;..\..\..\..\external\sdk13\components\libraries\bootloader\ble_dfu;..\..\..\..\external\sdk13\components\libraries\bootloader\dfu;..\..\..\..\external\sdk13\components\libraries\crc32;..\..\..\..\external\sdk13\components\libraries\crypto;..\..\..\..\external\sdk13\components\libraries\crypto\backend\micro_ecc;..\..\..\..\external\sdk13\components\libraries\crypto\backend\nrf_crypto_sw;..\..\..\..\external\sdk13\components\libraries\experimental_section_vars;..\..\..\..\external\sdk13\components\libraries\fstorage;..\..\..\..\external\sdk13\components\libraries\hci;..\..\..\..\external\sdk13\components\libraries\log;..\..\..\..\external\sdk13\components\libraries\log\src;..\..\..\..\external\sdk13\components\libraries\mem_manager;..\..\..\..\external\sdk13\components\libraries\queue;..\..\..\..\external\sdk13\components\libraries\scheduler;..\..\..\..\external\sdk13\components\libraries\sha256;..\..\..\..\external\sdk13\components\libraries\strerror;..\..\..\..\external\sdk13\components\libraries\svc;..\..\..\..\external\sdk13\components\libraries\timer;..\..\..\..\external\sdk13\components\libraries\util;..\..\..\..\external\sdk13\components\softdevice\common\softdevice_handler;..\..\..\..\external\sdk13\components\softdevice\s132\headers;..\..\..\..\external\sdk13\components\softdevice\s132\headers\nrf52;..\..\..\..\external\sdk13\components\toolchain;..\..;..\..\..\dfu_req_handling;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x70000 size 0xe000
  memory RVCT9: RAM 0x20002060 size 0xdf20
  link misc: --diag_suppress 6330
  group None
    ../../../dfu_req_handling/: dfu-cc.pb.c dfu_req_handling.c
    ../../: dfu_public_key.c
  group Application
    ../../: main.c thingy_dfu.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../external/sdk13/components/boards/: boards.c
  group nRF_BLE
    ../../../../external/sdk13/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_DFU
    ../../../../external/sdk13/components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ../../../../external/sdk13/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c nrf_bootloader_info.c
    ../../../../external/sdk13/components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Drivers
    ../../../../external/sdk13/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../external/sdk13/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../external/sdk13/components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../../sdk_components/drivers_nrf/twi_master/: nrf_drv_twi.c
  group nRF_Libraries
    ../../../../external/sdk13/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../external/sdk13/components/libraries/scheduler/: app_scheduler.c
    ../../../../external/sdk13/components/libraries/timer/: app_timer.c
    ../../../../external/sdk13/components/libraries/crc32/: crc32.c
    ../../../../external/sdk13/components/libraries/fstorage/: fstorage.c
    ../../../../external/sdk13/components/libraries/hci/: hci_mem_pool.c
    ../../../../external/sdk13/components/libraries/mem_manager/: mem_manager.c
    ../../../../external/sdk13/components/libraries/queue/: nrf_queue.c
    ../../../../external/sdk13/components/libraries/strerror/: nrf_strerror.c
    ../../../../external/sdk13/components/libraries/sha256/: sha256.c
  group nRF_Log
    ../../../../external/sdk13/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../external/sdk13/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_crypto
    ../../../../external/sdk13/components/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group nRF_crypto_backend
    ../../../../external/sdk13/components/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ../../../../external/sdk13/components/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
  group nRF_micro_ecc
    ../../../../external/sdk13/external/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../../../../external/nano-pb/: pb_common.c pb_decode.c
  group Thingy_Drivers
    ../../../../source/drivers/: drv_ext_light.c drv_sx1509.c drv_ext_gpio.c
    ../../../../source/util/: sx150x_led_drv_calc.c twi_manager.c support_func.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.12.0
